# Repository rahmant3/polymath-iot

File README.md:

# Polymath-IoT

This project is a submission for the Climate Change Challenge hosted by Quicklogic Corp.: https://www.quicklogic.com/climate-change-challenge/

## Overview

Polymath-IoT is a generic sensor cluster consisting of two separate modules that connect together, a controller module and sensor module. The module is intended to be attached to a room and passively collect and publish data over BLE.

The controller module consists of a two-micro system, with the slave system acting as an IO expander, and the master module collecting the data and publishing it over BLE.

The sensor module simply contains all of the sensors for a particular sensor cluster, and connects to the controller module. For this competition our focus was on creating a sensor cluster for collecting air quality data.

## Directory Structure
- hardware -- Contains the schematic for the Polymath system, as well as the files needed to build the PCB for the system.
- quickfeather -- Contains the documentation and source code for the master controller of the Polymath system, hosted on a Quickfeather board.
- stm32 -- Contains the documentation and source code for the slave controller of the Polymath system, hosted on an STM32 micro.
- utils -- Contains utility scripts used to support this project, such as Python scripts used to obtain training data from the system over BLE.

## KiCad design quickfeather/source/qorc-sdk/TinyFPGA-Programmer-Application/b-series/board/TinyFPGA-B.kicad_pcb

File quickfeather/README.md:

# polymath-iot (Quickfeather)
This repo contains the source code for polymath-iot (Quickfeather controller portion).

## Directory Structure
- source -- Contains the source code for this project
- source/app -- Contains the application specific code created by us.
- source/fpga -- Contains the fpga logic for the application.
- source/qorc-sdk -- Contains the SDK source the application is built on top of. Copied from here: https://github.com/QuickLogic-Corp/qorc-sdk

## Computer Setup (Command Line)
This project requires the following tools:
- Windows 10 workstation
- WSL (Windows Subsystem for Linux) installed. Note that Linux is only used for building the project with Make -- otherwise we will just use regular Windows 10 (e.g. Python, pip, etc).
  - The GCC-ARM toolchain must be installed to WSL like below.
  
    1. Download `"gcc-arm-none-eabi-9-2020-q2-update-x86_64-linux.tar.bz2"` tarball from: https://developer.arm.com/tools-and-software/open-source-software/developer-tools/gnu-toolchain/gnu-rm/downloads

    2. Extract the tarball to /usr/share.

        `sudo tar xvjf gcc-arm-none-eabi-9-2020-q2-update-x86_64-linux.tar.bz2 -C /usr/share/`

  - (Optional) To build the FPGA logic, the Quicklogic FPGA toolchain must be installed to WSL like below.

    1. Download `"Symbiflow_v1.3.1.gz.run"` to the `source` directory from: https://github.com/QuickLogic-Corp/quicklogic-fpga-toolchain/releases/tag/v1.3.1

    2. From the `source` directory, issue the following commands.

       `export INSTALL_DIR="$PWD/source/qorc-sdk/quicklogic-fpga-toolchain/install"`
        `bash Symbiflow_v1.3.1.gz.run`

- Python 3.6 or higher is need to reprogram the application (install a Windows version). 
    - TinyFPGA must be installed to the system. See the instructions here: https://github.com/QuickLogic-Corp/TinyFPGA-Programmer-Application

- Visual Studio Code (VSCode) is used as the IDE: https://code.visualstudio.com/
  - After installing VSCode, make sure to install the "C/C++" Extension from Microsoft.

## Build (Command Line)

### Application

In order to build the project, issue the following from a windows command line.

  `wsl bash build_app.sh`

In order to clean the project, issue the following from a windows command line.

  `wsl bash build_app.sh clean`

### FPGA Logic

(Optional) In order to build the FPGA logic, issue the following from a windows command line.

  `wsl bash build_fpga.sh`

## Eclipse

In order to set up the application to build and Debug using Eclipse, refer to the documentation in **source/app/GCC_Project/EclipseReadme.txt**. Note that:

1. When instructed to enter `make -C ${workspace_loc:/${ProjName}}/../` as the build command for Eclipse, you can instead enter `${workspace_loc:/${ProjName}}/../eclipse_build.bat ${workspace_loc:/${ProjName}}`. This was done to workaround build failures due to dependency files.

2. When debugging, the app.elf file is used (not a .bin file).

3. When debugging an application with JLink, the bootstrap mode should not be enabled (i.e. the shunts for J1 and J7 should not be installed).

## Useful References

* [Quickfeather Board User Guide](https://github.com/QuickLogic-Corp/quick-feather-dev-board/blob/master/doc/QuickFeather_UserGuide.pdf)
* [Quickfeather Board Schematic](https://github.com/QuickLogic-Corp/quick-feather-dev-board/blob/master/doc/quickfeather-board.pdf)
* [EOS S3 Datasheet](https://www.quicklogic.com/wp-content/uploads/2020/12/QL-EOS-S3-Ultra-Low-Power-multicore-MCU-Datasheet-2020.pdf)
* [SensiML + Quickfeather](https://sensiml.com/documentation/firmware/quicklogic-quickfeather/quicklogic-quickfeather.html)

Board: 2 copper layers, 17.8 x 35.6 mm, 36 parts (2 on the bottom side), 35 nets.

Parts:
C1, C2, C3, C4: 1uF; C_0402_NoSilk
C5, C7, C8, C9, C10, C11, C16: 100nF; C_0402_NoSilk
C6, C17: 10uF; C_0603
C12, C13, C14, C15: 10nF; C_0402_NoSilk
J1, J2: CONN_01X14; Pin_Header_Straight_1x14_Pitch2.54mm
J3: USB_OTG; USB_Micro-B_Molex_47346-0001
L1: Bead; L_0603
R1: 1.5k; R_0402_NoSilk
R2, R3: 68; R_0402_NoSilk
R4: 100; R_0402_NoSilk
R5, R7: 10k; R_0402_NoSilk
R6: 100; R_0402
SW1: SW_Push; PTS_810_SMT_Switch
TP1, TP2: TEST; Measurement_Point_Round-SMD-Pad_Small
U1: iCE40-LP8K-CM81; CM81
U2: MIC5504-3.3YM5-TR; SC-70-C5
U3: DSC6001CI2A-016.0000T; CDFN3225-4LD-PL-1
U4: MIC5365-1.2YC5-TR; SC-70-C5
U5: AT25SF041-SSHD-B; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
2B: J1.5, U1.B2, U1.B3, U1.C2, U1.C3
3A: J1.8, U1.B1
3B: J1.9, U1.C1
10A: J1.10, U1.D1
10B: J1.11, U1.E1
24B: J1.12, U1.G1
54: J1.13, U1.H1
55: J1.14, U1.J1
116: J2.7, U1.A9
119: J2.10, U1.D9
141_GBIN2: J2.8, U1.D7, U1.D8, U1.E7, U1.E8
148: J2.9, U1.C9
174: J2.6, U1.A8
177: J2.5, U1.A7
185: J2.4, U1.A6
221: J1.6, U1.A2
224: J1.7, U1.A1
+1V2: C3.1, C11.1, C12.1, C13.1, J2.3, R4.2, U1.D2, U1.D3, U1.D4, U1.E2, U1.E9, U1.F1, U1.F2, U4.5
+3V3: C2.1, C4.1, C5.1, C8.1, C9.1, C10.1, C14.1, C15.1, C16.1, J2.2, R1.2, R5.1, R6.1, U1.A5, U1.B6, U1.B7, U1.B8, U1.B9, U1.C6, U1.C8, U1.H3, U1.H8, U1.J2, U1.J5, U1.J9, U2.4, U2.5, U3.1, U3.4, U4.1, U4.3, U5.8
+5V: C1.1, C17.1, J2.1, L1.1, U2.1, U2.3
CLK: J1.4, U1.B4, U1.B5, U1.C4, U1.C5, U3.3
CRESET_B: R6.2, SW1.2, TP2.1, U1.H5, U1.H6, U1.J4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.1, J3.5, J3.6, R7.2, SW1.1, U1.E4, U1.E5, U1.F4, U1.F5, U1.F6, U1.F9, U2.2, U3.2, U4.2, U5.4
unnamed: C6.1, C7.1, U1.J6
unnamed: C6.2, C7.2, R4.1, U1.J7
unnamed: J3.1, L1.2
unnamed: J3.2, R3.2
unnamed: J3.3, R1.1, R2.2
unnamed: R7.1, TP1.1, U5.3
SCK: J2.12, U1.G7, U1.G8, U1.H9, U5.6
SDI: J2.13, U1.H7, U1.J8, U5.2
SDO: J2.14, U1.G5, U1.G6, U1.H4, U1.J3, U5.5
SS: J2.11, R5.2, U1.F7, U1.F8, U1.G9, U5.1
USB_N: J1.3, R3.1, U1.A4
USB_P: J1.2, R2.1, U1.A3

## KiCad design quickfeather/source/qorc-sdk/TinyFPGA-Programmer-Application/a-series-programmer/board/TinyFPGA-A-Programmer.kicad_pcb

File quickfeather/source/qorc-sdk/TinyFPGA-Programmer-Application/a-series-programmer/README.md:

# TinyFPGA Programmer ##
The TinyFPGA Programmer is a very simple USB-JTAG bridge designed to 
program bitstreams onto TinyFPGA A1 and A2 boards.  

## Serial Protocol
The programmer firmware appears as a generic USB serial port when you connect it
to a computer.  Control of the GPIO pins on the programmer is through this simple
serial interface.  

### Command Format
Commands are encoded as 8-bit bytes with a command type field and data payload.
The payload is typically a 6-bit bitmap representing the GPIO pins of the programmer.

|      7:6     | 5 | 4 | 3 | 2 | 1 | 0 |
|--------------|---|---|---|---|---|---|
| Command Type |TMS|TCK|TDI|TDO|RC1|RC0|

### Commands

|Opcode |             Command           |
|-------|-------------------------------|
|   0   | Configure Input/Output        |
|   1   | Extended Command (Unused)     |
|   2   | Set Outputs                   |
|   3   | Set Outputs and Sample Inputs |

#### Configure Input/Output
For each of the GPIO pins, set the direction of the pin.  
* 1: Set GPIO pin n to INPUT
* 0: Set GPIO pin n to OUTPUT

#### Extended Command
Reserved for future command expansion.

#### Set Outputs
Set each of the output pins to the given values.

#### Set Outputs and Sample Inputs
Set each of the output pins to the given values and return a byte representing
the current values of the input pins.  

### General Usage
For serial interfaces like JTAG this protocol divides the maximum possible bandwidth
by 8 from the USB to JTAG interface.  This means we might get 0.5MHz JTAG programming speed.
That speed is actually fast enough to transfer all the data to the FPGA in a few seconds.  However
the configuration flash on the FPGA actually needs a fair bit of time after erase and write operations
that will slow down the programming operatuon.

What can really slow down programming is the turnaround time for reading back data from the FPGA.  
For the most part data is going in one direction from the host computer to the programmer to the FPGA.  
For these cases we can  use the `Set Outputs` command and not wait for any data to return.  However 
there are times when we may  need to poll a status bit to see if the FPGA has finished an erase or 
write operation.  In this cases we will want to also sample the inputs and check the status.  These 
should not be timing sensitive because the FPGA is already busy.

Verifying the configuration data on the other hand could take a long time if not done carefully.  The
application talking to the programmer should make sure to write as many commands as it can before attempting
to read back the data from the serial interface.  Rather than paying a penalty for the turnaround time on
every read bit, we pay for it after reading dozens of bytes.  This should allow read-back of the configuration
data to be relatively quick and painless.

## Status
The project is currently in progress.  Initial schematic and PCBs have
been designed along with firmware for the USB microcontroller.  The PCBs
have been received from OSH Park and programmed with the firwmware.

The biggest task left is still developing the Python libraries for interfacing 
with the firmware and driving the JTAG interface and is currently in progress.

Board: 2 copper layers, 17.8 x 30.5 mm, 16 parts (3 on the bottom side), 15 nets.

Parts:
C1, C2, C4: 1uF; C_0603
C3: 100nF; C_0603
D+: TEST; Measurement_Point_Round-SMD-Pad_Small
D-: TEST; Measurement_Point_Round-SMD-Pad_Small
J1: USB; FCI-Micro-USB
J2: JTAG; Pin_Header_Straight_1x05_Pitch2.54mm_SMD
J2#2, J2#3, J2#4: JTAG; Pin_Header_Straight_1x05_Pitch2.54mm
J3: ICSP; Pin_Header_Straight_1x06_Pitch2.54mm
J4: CONN_01X06; Pin_Header_Straight_1x06_Pitch2.54mm
U1: PIC16F1455-QFN16; QFN-16-1EP_4x4mm_Pitch0.65mm
U2: MIC5504-3.3YM5-TR; SOT23
VUSB: TEST; Measurement_Point_Round-SMD-Pad_Small

Connections:
+3V3: C2.1, C3.1, J3.2, J4.2, U1.16, U2.4, U2.5
+5V: C1.1, J1.1, U2.1, U2.3, VUSB.1
GND: C1.2, C2.2, C3.2, C4.1, J1.5, J1.6, J2.4, J2#2.4, J2#3.4, J2#4.4, J3.3, J4.1, U1.13, U2.2
ICSPCLK: J3.5, J4.6, U1.8
ICSPDAT: J3.4, J4.5, U1.9
unnamed: C4.2, U1.10
unnamed: D-.1, J1.2, U1.11
unnamed: D+.1, J1.3, U1.12
unnamed: J2.1, J2#2.1, J2#3.1, J2#4.1, U1.4
unnamed: J2.2, J2#2.2, J2#3.2, J2#4.2, U1.5
unnamed: J2.3, J2#2.3, J2#3.3, J2#4.3, U1.6
unnamed: J2.5, J2#2.5, J2#3.5, J2#4.5, U1.7
RA4: J4.4, U1.2
RA5: J4.3, U1.1
VPP: J3.1, U1.3

## Commit log

2021-01-16 Create baseline app and SDK folders.
2021-01-16 Commit missing s3-gateware files.
2021-01-16 Updated to build properly.
2021-01-16 Created README.md.
2021-01-24 Created a revision of pm_protocol.h.
2021-01-24 Switch to the last tested GCC toolchain, to minimize risk of incompatibilities with the SDK.
2021-01-24 Ignore build artifacts.
2021-01-24 Added Python ignores.
2021-01-24 Added script and source to perform programming with TinyFPGA.
2021-01-24 Created VSCode task with a default task that can build the app in VSCode WSL.
2021-01-24 Try enabling the DEBUG USB UART.
2021-02-07 Updates to support development on Eclipse.
2021-02-07 Additional updates to support Eclipse builds.
2021-02-07 Update eclipse_build.bat to handle cleaning.
2021-02-21 Setup infrastructure for supporting custom CLI commands for Polymath.
2021-02-26 Additional changes to support using USBSERIAL as the data capture port.
    The reliability of the USBSERIAL is improved due to this forum post: https://forum.quicklogic.com/viewtopic.php?f=9&t=95
2021-02-27 Enough functionality to use USBSERIAL for both CLI and data capture.
2021-03-27 Clear app folder in order to restart with fpga uart project.
2021-03-27 Commit baseline with fpga-uart project.
2021-03-27 Update to properly build fpga-uart project.
2021-03-27 Enough support to build FPGA project from qorc-sdk folder.
2021-03-27 Commit fUART pga IP project from qorc-sdk.
2021-03-27 Build support for FPGA project.
2021-03-27 Update makefile to work with FPGA bitstream header file.
2021-03-27 Change one FPGA UART to IO_2, IO_13.
2021-04-02 Initial implementation of pm_protocol.h.
2021-04-03 Implement pm_core module.
2021-04-03 Added eclipse_build.bat.
2021-04-03 Improvements to pm_protocol module.
2021-04-03 Correction to pm_core.c implementation.
2021-04-03 Slave SW TEST
    Added Slave SW for UART TEST
2021-04-03 QF UART test with hard uart.
2021-04-04 Successful test with pm_protocol loopback test.
2021-04-04 Bugfixes to pm_protocol.c
2021-04-04 Enhancements to pm_protocol to handle decoding and encoding raw packets.
2021-04-04 Add ack after receiving the first two bytes.
2021-04-10 Bugfixes and additional tests.
2021-04-17 Preliminary bt121 testing.
2021-04-17 Initial nrf51 working code.
2021-04-17 Added functionality for BLE over UART RX.
2021-04-18 Successful bluetooth tests with Mock Air Cluster implementation.
2021-04-18 Added BME680 files
2021-04-24 Added initial training code.
2021-04-24 Added slave code for STM32L476 NUCLEO board.
2021-04-24 Added more code to support training.
2021-04-24 Added BME680 updates.
2021-05-02 Added support for collecting training data.
2021-05-02 Updates to support collecting training data.
2021-05-02 Added hardware files from SLAVE_UART_TEST.
2021-05-16 Added MICS
2021-05-16 refactor
2021-05-30 Updated Design files
2021-05-30 Updated slave controller software and documentation.
